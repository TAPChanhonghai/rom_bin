# IAR project Backup of E.B.W_BOOTLOADER.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32G232F128 EnergyMicro EFM32G232F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32G222F128; BSP_CORTEX_EFM32; __ICCAVR__
  ICCARM.CCIncludePath2: ; Include; emlib\inc; Device\EnergyMicro\EFM32G\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ROM_V_31.bin
  ILINK.IlinkOutputFile: IOEFM.out
  ILINK.IlinkIcfFile: Config.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    Device/EnergyMicro/EFM32G/Source/IAR/: startup_efm32g.s
    Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group emlib
    emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group Local
    ./: boot.c Com_APP.c Comm.h HW.c JISFlash.c JisTimer.c JIStypes.h Logger.h main.c system.c
