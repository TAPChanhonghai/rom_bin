# IAR project E.B.W_BOOTLOADER.ewp, settings and files
configuration bootForPower100w (ARM, debug)
  General.OGChipSelectEditMenu: EFM32G232F128 EnergyMicro EFM32G232F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32G232F128; BSP_CORTEX_EFM32; __ICCAVR__; DEBUG_MS_REPRINTF; _SP100W_
  ICCARM.CCIncludePath2: ; Include; emlib\inc; Device\EnergyMicro\EFM32G\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NewBootLoaderFor100WPowerDebug.bin
  ILINK.IlinkOutputFile: power100w.out
  ILINK.IlinkIcfFile: bootFor100WPower.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration bootForCommon (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EFM32G232F128; BSP_CORTEX_EFM32; __ICCAVR__; DEBUG_MS_REPRINTF
  OBJCOPY.OOCOutputFile: NewBootLoaderForCommonDebug.bin
  ILINK.IlinkOutputFile: common.out
  ILINK.IlinkIcfFile: boot.icf
configuration bootFor100WPowerRelease (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EFM32G232F128; BSP_CORTEX_EFM32; __ICCAVR__; _SP100W_
  OBJCOPY.OOCOutputFile: NewBootLoaderFor100WPowerRelease.bin
  ILINK.IlinkOutputFile: power100wRelease.out
configuration bootForCommonRelease (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EFM32G232F128; BSP_CORTEX_EFM32; __ICCAVR__
  OBJCOPY.OOCOutputFile: NewBootLoaderForCommonRelease.bin
  ILINK.IlinkOutputFile: CommonRelease.out
  ILINK.IlinkIcfFile: boot.icf
  group CMSIS
    Device/EnergyMicro/EFM32G/Source/IAR/: startup_efm32g.s
    Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group emlib
    emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group Local
    ./: boot.c Com_APP.c Comm.h HW.c JISFlash.c JisTimer.c JIStypes.h Logger.h main.c system.c
